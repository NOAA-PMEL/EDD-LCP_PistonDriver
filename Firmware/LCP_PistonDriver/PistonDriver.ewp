# IAR project PistonDriver.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsdn.h
  General.OGChipSelectMenu: MSP430FR5989 MSP430FR5989
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430fr5989.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ./: main.c
  group src/driverlib
    src/driverlib/: adc12_b.c adc12_b.h aes256.c aes256.h comp_e.c comp_e.h crc.c crc.h crc32.c crc32.h cs.c cs.h dma.c dma.h driverlib.h esi.c esi.h eusci_a_spi.c eusci_a_spi.h eusci_a_uart.c eusci_a_uart.h eusci_b_i2c.c eusci_b_i2c.h eusci_b_spi.c eusci_b_spi.h framctl.c framctl.h framctl_a.c framctl_a.h gpio.c gpio.h hspll.c hspll.h lcd_c.c lcd_c.h mpu.c mpu.h mpy32.c mpy32.h mtif.c mtif.h pmm.c pmm.h ram.c ram.h ref_a.c ref_a.h rtc_b.c rtc_b.h rtc_c.c rtc_c.h saph.c saph.h saph_a.c saph_a.h sdhs.c sdhs.h sfr.c sfr.h sysctl.c sysctl.h timer_a.c timer_a.h timer_b.c timer_b.h tlv.c tlv.h uups.c uups.h wdt_a.c wdt_a.h
  group src/driverlib/inc
    src/driverlib/inc/: hw_memmap.h version.h
