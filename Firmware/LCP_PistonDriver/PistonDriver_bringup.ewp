# IAR project PistonDriver_bringup.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlldn.h
  General.OGChipSelectMenu: MSP430FR5989 MSP430FR5989
  General.GStackSize2: 256
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: DEBUG; DEBUG_LED; DEBUG_UART; INCLUDE_CONSOLE
  ICC430.newCCIncludePaths: C:\version-control\EDD-LCP_PistonDriver\Firmware\LCP_PistonDriver\src
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  prebuild: CMD /C "..\CI_scripts\IAR_Prebuild.bat" ..
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430fr5989.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ./: main.c version.h
  group src
    src/: buffer_c.c buffer_c.h config.h DRV8874.c DRV8874.h encoder.c encoder.h logging.c logging.h memory.c memory.h piston.c piston.h shell.c shell.h shell_commands.c shell_commands.h sysinfo.c sysinfo.h
  group src/bsp
    src/bsp/: bsp.c bsp.h bsp_adc12.c bsp_adc12.h bsp_dma.c bsp_dma.h bsp_esi.c bsp_esi.h bsp_esi_cal.c bsp_esi_cal.h bsp_gpio.c bsp_gpio.h bsp_led.c bsp_led.h bsp_pins.c bsp_pins.h bsp_pwm.c bsp_pwm.h bsp_uart.c bsp_uart.h
  group src/driverlib
    src/driverlib/: adc12_b.c adc12_b.h aes256.c aes256.h comp_e.c comp_e.h crc.c crc.h crc32.c crc32.h cs.c cs.h dma.c dma.h driverlib.h esi.c esi.h eusci_a_spi.c eusci_a_spi.h eusci_a_uart.c eusci_a_uart.h eusci_b_i2c.c eusci_b_i2c.h eusci_b_spi.c eusci_b_spi.h framctl.c framctl.h framctl_a.c framctl_a.h gpio.c gpio.h hspll.c hspll.h lcd_c.c lcd_c.h mpu.c mpu.h mpy32.c mpy32.h mtif.c mtif.h pmm.c pmm.h ram.c ram.h ref_a.c ref_a.h rtc_b.c rtc_b.h rtc_c.c rtc_c.h saph.c saph.h saph_a.c saph_a.h sdhs.c sdhs.h sfr.c sfr.h sysctl.c sysctl.h timer_a.c timer_a.h timer_b.c timer_b.h tlv.c tlv.h uups.c uups.h wdt_a.c wdt_a.h
  group src/driverlib/inc
    src/driverlib/inc/: hw_memmap.h version.h
  group src/system
    src/system/: CS_A_init.c DMA_init.c EUSCI_A0_init.c EUSCI_A1_init.c EUSCI_B0_init.c EUSCI_B1_init.c FRCTL_init.c GPIO_init.c Interrupts.c PMM_init.c RTC_B_init.c System.c System.h Timer0_A3_init.c Timer2_A2_init.c Timer3_A2_init.c WDT_A_init.c
